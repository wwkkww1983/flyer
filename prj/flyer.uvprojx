# Keil uVision project flyer.uvprojx, settings and files
target flyer (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flyer
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: EMPL_TARGET_STM32F4,MPU9250,EMPL_TARGET_STM32F4,ARM_MATH_CM4,__FPU_PRESENT
  c include: E:\Keil_v5\STM32Cube_FW_F4\Drivers\CMSIS\Include;E:\Keil_v5\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\src\eMD6.12\core\driver\eMPL;..\src\hal;..\src\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group st
    E:/Keil_v5/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
    E:/Keil_v5/STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group inv
    ../src/eMD6.12/core/driver/eMPL/: inv_mpu.c
  group main
    ../src/main/: fusion.c lib_math.c main.c systick.c data.c pid.c
  group hal
    ../src/hal/: console.c imu.c misc.c mpu9250.c board.c stm32f4xx.s pwm.c
