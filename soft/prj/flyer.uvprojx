# Keil uVision project flyer.uvprojx, settings and files
target flyer (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flyer
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: EMPL_TARGET_STM32F4,MPU9250,AK89xx_BYPASS,ARM_MATH_CM4
  c include: ..\thd\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\thd\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\thd\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\thd\eMD6.12\core\driver\eMPL;..\thd\eMD6.12\core\driver\include;..\thd\eMD6.12\core\mllite;..\thd\bmp280;..\src;..\src\app;..\src\lib;..\src\drv;..\src\bsp;..\src\bsp\sensor
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group st
    ../thd/STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../thd/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group lib
    ../src/lib/: misc.c lib_math.c
  group drv
    ../src/drv/: stm32f4xx.s uart.c systick.c exti.c
  group chip
    ../thd/eMD6.12/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../thd/eMD6.12/core/mllite/: ml_math_func.c mlmath.c
  group bsp
    ../src/bsp/: console.c board.c esp8266.c led.c pwm.c si.c mpu9250.c inv.c comm.c
  group app
    ../src/app/: main.c
